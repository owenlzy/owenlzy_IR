# Keil uVision project Project.uvproj, settings and files
target HY-FireBull V1.0 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\USER;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\USER\ucCos_App;..\USER\uC-CPU;..\USER\uC-LIB;..\USER\uCOS-II;..\USER\uCOS-VIEW;..\USER\lwip-1.3.2;..\USER\lwip-1.3.2\src;..\USER\lwip-1.3.2\src\api;..\USER\lwip-1.3.2\src\netif;..\USER\lwip-1.3.2\src\core;..\USER\lwip-1.3.2\src\arch;..\USER\lwip-1.3.2\src\include;..\USER\lwip-1.3.2\src\core\ipv4;..\USER\lwip-1.3.2\src\include\lwip;..\USER\lwip-1.3.2\src\include\netif;..\USER\lwip-1.3.2\src\include\arch;..\USER\lwip-1.3.2\src\include\ipv4\lwip;..\USER\ENC28J60;..\USER\GLCD;..\USER\uCGUI\inc;..\USER\uCGUI\Config;..\USER\usart;..\USER\dma;..\USER\PWM;..\USER\ADC;..\USER\SD_card;..\USER\ttp224;..\USER\ultrasonic;..\USER\encode;..\USER\SPI_SD_Card;..\USER\FATFS_V0.08A\src;..\USER\GPIO;..\USER\ESP8266;..\USER\LED;..\USER\delay;..\USER\motor;..\USER\exit;..\USER\RTC;..\USER\REMOTE;..\USER\BSP;..\USER\xlib\xCLI;..\USER\SYSTEM\delay;..\USER\SYSTEM\sys;..\USER\SYSTEM\key;..\USER\xlib\BSP;..\USER\xlib\Picoc;..\USER\xlib\Picoc\core;..\USER\xlib\Picoc\cstdlib;..\USER\distance;..\USER\human;..\USER\key;..\USER\LEDArry;..\USER\ServoHand;..\USER\8X8;..\USER\LCD12864;..\USER\digitron;..\USER\Flash;..\USER\Beep;..\USER\fall
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../USER/: main.c stm32f10x_it.c stm32f10x_conf.h
    ../USER/ucCos_App/: uctsk_OSView.c includes.h app_cfg.h Pout.h uctsk_xfTTS.c
  group uC-OS-II/Port
    ../USER/uCOS-II/Ports/ARM-Cortex-M3/RealView/: os_dbg.c os_cpu_c.c os_cpu.h os_cpu_a.asm
  group uC-OS-II/CPU
    ../USER/uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu_a.asm cpu.h
    ../USER/uC-CPU/: cpu_def.h
  group uC-OS-II/Source
    ../USER/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC-OS-II/LIB/Source
    ../USER/uC-LIB/: lib_mem.c lib_str.c lib_def.h lib_mem.h lib_str.h
  group uC-OS-II/Config
    ../USER/ucCos_App/: OS_AppHooks.c os_cfg.h
  group uC-OS-II/LIB/Port
    ../USER/uC-LIB/Ports/RealView/: lib_mem_a.asm
  group uC-OS-II/VIEW/Source
    ../USER/uCOS-VIEW/Source/: os_view.c os_view.h
  group uC-OS-II/VIEW/Port
    ../USER/uCOS-VIEW/Ports/ARM-Cortex-M3/Realview/: os_viewc.c os_viewc.h
  group Libraries/CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../USER/: system_stm32f10x.c
  group Libraries/StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Doc
    ../: readme.txt
  group usart
    ../USER/usart/: usart.c
  group dma
    ../USER/dma/: dma.c dma.h
  group PWM
    ../USER/PWM/: pwm.c
  group ADC
    ../USER/ADC/: adc.c
  group encode
    ../USER/encode/: encode.c
  group gpio
    ../USER/GPIO/: gpio.c
  group RTC
    ../USER/RTC/: RTC.c
